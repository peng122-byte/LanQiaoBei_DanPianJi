# Keil uVision project p1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: p1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group source
    ./: main.c Key.c Seg.c
    ../BSP/: ds1302.c iic.c onewire.c
  group head
    ./: ds1302.h iic.h onewire.h Key.h Seg.h
