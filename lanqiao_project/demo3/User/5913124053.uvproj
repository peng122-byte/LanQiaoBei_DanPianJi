# Keil uVision project 5913124053.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 5913124053 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
  group Driver
    ../Driver/: Key.c ds1302.c iic.c onewire.c
