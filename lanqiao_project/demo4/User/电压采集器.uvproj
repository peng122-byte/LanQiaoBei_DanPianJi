# Keil uVision project 电压采集器.uvproj, settings and files
target pzk (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 电压采集器 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ../Driver/: Key.c Led.c Seg.c
  group User
    ./: main.c
