# Keil uVision project pzk.uvproj, settings and files
target pzk (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pzk +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Driver
    ./Driver/: iic.c Init.c Key.c LED.c onewire.c Seg.c
