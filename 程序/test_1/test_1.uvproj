# Keil uVision project test_1.uvproj, settings and files
target test_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
