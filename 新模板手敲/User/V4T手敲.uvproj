# Keil uVision project V4T手敲.uvproj, settings and files
target pzk (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: V4T手敲 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: Key.c Seg.c LED.c Init.c ds1302.c onewire.c iic.c
